# Keil uVision project Project.uvprojx, settings and files
target STM32F4-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4-Discovery +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO
  c include: ..\Libraries\STM32F4xx_HAL_Driver\Inc;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\Drivers\inc;..\Libraries\SYSTEM\sys;..\Libraries\SYSTEM\delay;..\Libraries\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: startup_stm32f407xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f407xx.h system_stm32f4xx.h
  group LIBS
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Doc
    ../: readme.txt
  group User
    ../User/: main.c stm32f4xx_it.c stm32f4xx_hal_conf.h
  group Drivers
    ../Drivers/src/: usart.c gpio.c
    ../Libraries/SYSTEM/delay/: delay.c
    ../Libraries/SYSTEM/sys/: sys.c
    ../Libraries/SYSTEM/usart/: dbg_usart.c
software components: CMSIS:CORE 5.6.0
